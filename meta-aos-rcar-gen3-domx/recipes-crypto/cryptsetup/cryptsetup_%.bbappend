# initramfs is build without this lib runtime
RDEPENDS:${PN} += "libgcc"
